PR = "r1"

SYSTEMD_AUTO_ENABLE:${PN} = "disable"
